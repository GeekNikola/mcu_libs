# Keil uVision project Simulation.uvprojx, settings and files
target Simulation (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: simulation
  AfterMake: D:\Project\mcu_libs\examples\Keil_STM32F103\CORTEX_STM32F103_Keil\keil5_disp_size_bar.exe
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: RVDS_ARMCM3_LM3S102
  c include: ..\CORTEX_STM32F103_Keil;..\Common\include;.\STM32F10xFWLib\inc;..\..\..\inc;..\..\..\test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./: STM32F10x.s stm32f1xx_it.c
    ../Common/drivers/ST/STM32F10xFWLib/src/: cortexm3_macro_rvds.s
    ./STM32F10xFWLib/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c
  group Demo Files
    ./serial/: serial.c
    ./: timertest.c main.c
  group mcu_libs
    ../../../src/utilities/: mcu_events.c mcu_libs.c mcu_loger.c tlsf.c
  group test
    ../../../test/: test_list.c test_ring_buf.c
